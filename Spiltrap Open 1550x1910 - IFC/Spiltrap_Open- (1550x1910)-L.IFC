Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], Export from Compass
File name: Architecten pagina_Spiltrap_Open- (1550x1910)-L.IFC
Time: 2019-07-25T16:07:24
Author: Compass
Organization: Compass Software GmbH
Written by: De Vries Trappen BV
Made in: De Vries Trappen BV
Authorization: staircase file created for IFC import

# IfcBuildingElementPart: IFCStair (23)
In: Buildingstorey
Group: STAIR - OTHERS

# IfcGroup: IFCStair, STAIR - OTHERS
Description: OTHERS; Group: Stair assembly

# IfcStair, Open- (1550x1910)-L
In: Buildingstorey
Description: staircase; ShapeType: TWO_QUARTER_WINDING_STAIR
CS_Set_Dimensions - Aantrede: 220 mm; Optredehoogte: 181.25 mm; Doorloophoogte: 2624.43 mm
CS_Set_Materials - Treden: vuren; Stootborden: mdf; Spil: grenen fsc mix; Bomen: vuren
CS_Set_Others - Barcode: 9A26; Auftragsname:: Architecten pagina; Specificaties: Voor deze trap gelden de specificaties en detailleringen als beschreven in de (meest recente) separaat verzonden specificatiebladen.; Voorbehoud: Aan dit model kunnen geen rechten worden ontleend t.a.v. materiaal, kleur en profilering.; Bestekparagraaf (Stabu): NL_32
